<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tx_HDLC_doppler_simplified</value></param>
<param><key>author</key><value>Dan Álvarez</value></param>
<param><key>description</key><value>This block transmits CSP commands in HDLC encoding and GMSK modulation.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Quetzal-1 Simplified Transmitter (w/ doppler)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bit_rate</value></param>
<param><key>value</key><value>4800</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>choose_photo_cmd</value></param>
<param><key>value</key><value>4</value></param>
<param><key>gui_hint</key><value>0,0,1,3</value></param>
<param><key>label</key><value>PHOTO COMMAND OPTIONS</value></param>
<param><key>labels</key><value>["HTR CYCLE TIME 30", "HTR CYCLE TIME 240", "CDHS CYCLE TIME 10", "CDHS CYCLE TIME 255", "PLD DISABLE", "PLD ENABLE", "PLD DOWNLOAD IMAGE", "PLD TAKE IMAGE", "PLD FULL OP"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2, 3, 4, 5, 6, 7, 8]</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>437200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>log</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod_index</value></param>
<param><key>value</key><value>0.66667</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>ptt</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>7,0,1,3</value></param>
<param><key>label</key><value>Push To Talk</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>comment</key><value>Used to shift 
the DC peak 
500 kHz away 
from the signal.</value></param>
<param><key>freq</key><value>-100e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>comment</key><value>Uncomment this
in case you don't
want to transmit
anything.</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>comment</key><value>Packs the bytes
for the GFSK Mod.</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>comment</key><value>Converts the message
data into a stream
of unpacked bytes.</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>digital_gfsk_mod</key>
<param><key>id</key><value>digital_gfsk_mod_0</value></param>
<param><key>bt</key><value>0.5</value></param>
<param><key>comment</key><value>samples/symbol was
set to 4 because we
observed it worked.</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>sensitivity</key><value>3.14159265*mod_index/sps</value></param>
</block>
<block>
<key>digital_scrambler_bb</key>
<param><key>id</key><value>digital_scrambler_bb_0</value></param>
<param><key>comment</key><value>This corresponds to
a G3RUH scrambler
according to Estevez, D.</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>generate_command</value></param>
<param><key>choose_photo_cmd</key><value>choose_photo_cmd</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
import pylab
from gnuradio import gr
import pmt
import time
import serial


class msg_block(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
	"""
	This block sends commands within a CSP frame when a message is received on the input.
	This is a simplified version of the transmitter, optimized for photo downloads.
	
	Inputs:
	- ptt: when 0, tx is off; when 1, tx is on.
	- choose_photo_cmd: contains the commands necessary to download a photo

	Outputs:
	- PMT type message containing a uint8 vector that contains the command encapsulated in the CSP frame.
	"""

	def __init__(self, ptt = 0, choose_photo_cmd = 4):
		"""arguments to this function show up as parameters in GRC"""
		gr.basic_block.__init__(
			self,
			name='Generate Command',   # will show up in GRC
			in_sig=None,
			out_sig=None
		)

		#######################
		# SERIAL PORT
		#######################
		# serial port is used to control the USB relay that controles the switch from RX to TX
		# if /dev/ttyACM1 throws any errors, check to see if dialout is within your group permissions. Use:
		# $ groups ${USER}
		# $ sudo gpasswd --add ${USER} dialout

		# UNCOMMENT THESE LINES WHEN USING THE RF RELAY IN THE GROUND CONTROL STATION
		# SINCE THE RF RELAY IS CONTROLLED BY THE USB RELAY
		self.ser = serial.Serial(
			port='/dev/ttyUSB0',
			baudrate=9600,
			parity=serial.PARITY_NONE,
			stopbits=serial.STOPBITS_ONE,
			bytesize=serial.EIGHTBITS
		)

		#######################
		# GUI VARIABLES
		#######################
		# if an attribute with the same name as a parameter is found,
		# a callback is registered (properties work, too).		
		self.ptt = ptt
		self.choose_photo_cmd = choose_photo_cmd

		#######################
		# CSP HEADER
		#
		# priority = 1
		# source = 7
		# destination = 1
		# destination port = 25		
		# source port = 7
		# reserved = 0
		# HMAC = 0
		# XTEA = 0
		# RDP = 0
		# CRC = 0
		#######################
		priority = int('{0:02b}'.format(1), 2)	
		source = int('{0:05b}'.format(7), 2)	
		destination = int('{0:05b}'.format(1), 2)
		destination_port = int('{0:06b}'.format(25), 2)
		source_port = int('{0:06b}'.format(7), 2)
		reserved = int('{0:04b}'.format(0), 2)
		hmac = int('{0:01b}'.format(0), 2)
		xtea = int('{0:01b}'.format(0), 2)
		RDP = int('{0:01b}'.format(0), 2)
		CRC = int('{0:01b}'.format(0), 2)

		CSP_header = (priority &lt;&lt; 30) | (source &lt;&lt; 25) | (destination &lt;&lt; 20) | (destination_port &lt;&lt; 14) | \
		(source_port &lt;&lt; 8) | (reserved &lt;&lt; 4) | (hmac &lt;&lt; 3) | (xtea &lt;&lt; 2) | (RDP &lt;&lt; 1) | CRC

		self.csp_byte1 = np.array([CSP_header &amp; 0xFF],np.uint8)
		self.csp_byte2 = np.array([(CSP_header &gt;&gt; 8) &amp; 0xFF],np.uint8) 
		self.csp_byte3 = np.array([(CSP_header &gt;&gt; 16) &amp; 0xFF],np.uint8)
		self.csp_byte4 = np.array([(CSP_header &gt;&gt; 24) &amp; 0xFF],np.uint8)

		#######################
		# VERIFICATION CODES
		#######################
		# verification code is 0x6F, 0x5D
		self.verByte1 = np.array([0x6f],np.uint8)
		self.verByte2 = np.array([0x5d],np.uint8)

		#######################
		# SIMPLIFIED PHOTO CMD
		# DICTIONARY
		#######################
		# simplified commands to capture photos
		# 0 = HTR CYCLE TIME 30
		# 1 = HTR CYCLE TIME 240
		# 2 = CDHS CYCLE TIME 10
		# 3 = CDHS CYCLE TIME 255
		# 4 = PLD DISABLE
		# 5 = PLD ENABLE
		# 6 = PLD DOWNLOAD IMAGE
		# 7 = PLD TAKE IMAGE
		# 8 = PLD FULL OP
		self.simplified_photo_cmds = {
			0: [0xa9,0xaf,30],
			1: [0xa9,0xaf,240],
			2: [0xa9,0xa9,10],
			3: [0xa9,0xa9,255],
			4: [0xa9,0xbf,0],
			5: [0xa9,0xbf,1],
			6: [0xf9,0xa9],
			7: [0xf9,0xaa],
			8: [0xf9,0xab]
			}
		
		#######################
		# CONFIG. MESSAGE
		# PORT
		#######################
		self.message_port_register_out(pmt.intern('msg_out'))
		self.message_port_register_in(pmt.intern('msg_in'))
		self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

	def handle_msg(self, msg):
		if self.ptt == 1: # only transmits when PTT button is pressed 
			
			# SET RELAYS FOR TX MODE
			self.ser.write(bytearray([0xa0,0x01,0x01,0xa2]))	# sets relays in TX mode
			time.sleep(0.35)									# give relays time to switch

			# GENERATE COMMAND DEPENDING ON USER SELECTIONS
			command = np.array(self.simplified_photo_cmds[self.choose_photo_cmd], np.uint8)

			# FORM CSP PACKET
			transmit = np.concatenate([
				self.csp_byte4,
				self.csp_byte3,
				self.csp_byte2,
				self.csp_byte1,
				self.verByte1,
				self.verByte2,
				command
			])

			# TRANSMIT
			# send N commands, the last one isnt transmitted due to flowgraph buffer issues
			for i in range(0,7):
				self.message_port_pub(pmt.intern('msg_out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(transmit)))

			# PRINT TO TERMINAL
			print "\n"
			print "Command: ", transmit
			print "\n"

			# BRING BACK RELAYS INTO RX MODE
			time.sleep(0.93)										# wait for commands to be transmitted
			self.ser.write(bytearray([0xa0,0x01,0x00,0xa1]))		# sets relays in RX mode

	def work(self, input_items, output_items):
		pass
</value></param>
<param><key>comment</key><value>Creates commands
encapsulated in a CSP
frame.

Remember to uncomment
lines to activate the USB Relay that
controls the RF Relay.</value></param>
<param><key>ptt</key><value>ptt</value></param>
</block>
<block>
<key>gpredict_MsgPairToVar</key>
<param><key>id</key><value>gpredict_MsgPairToVar_0</value></param>
<param><key>target</key><value>freq</value></param>
</block>
<block>
<key>gpredict_doppler</key>
<param><key>id</key><value>gpredict_doppler_0</value></param>
<param><key>comment</key><value>Only used when we wish to
correct for doppler shift
on TX.</value></param>
<param><key>gpredict_port</key><value>4532</value></param>
<param><key>gpredict_host</key><value>localhost</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>msgtools_variable_to_msg</key>
<param><key>id</key><value>msgtools_variable_to_msg_0</value></param>
<param><key>comment</key><value>Keys the transmitter.
It sends a message
when the ptt variable
changes.</value></param>
<param><key>key</key><value>1</value></param>
<param><key>value</key><value>ptt</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>freq0</key><value>freq+100e3</value></param>
<param><key>if_gain0</key><value>47</value></param>
<param><key>gain0</key><value>14</value></param>
<param><key>comment</key><value>Ensure the correct
hackrf is selected in
device arguments.

The TX HackRF's
argument is
hackrf=36135f.</value></param>
<param><key>args</key><value>hackrf=36135f</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>comment</key><value>Sets the baud
rate of the transmitted
data to 4800 bps.</value></param>
<param><key>decim</key><value>bit_rate*sps</value></param>
<param><key>interp</key><value>samp_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>satellites_hdlc_framer</key>
<param><key>id</key><value>satellites_hdlc_framer_0</value></param>
<param><key>comment</key><value>Adds start and stop
flags, the CRC and
performs bit stuffing.</value></param>
<param><key>postamble_bytes</key><value>0</value></param>
<param><key>preamble_bytes</key><value>50</value></param>
</block>
<block>
<key>satellites_nrzi_encode</key>
<param><key>id</key><value>satellites_nrzi_encode_0_0</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>digital_gfsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_scrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gfsk_mod_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_scrambler_bb_0</source_block_id><sink_block_id>satellites_nrzi_encode_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>generate_command</source_block_id><sink_block_id>satellites_hdlc_framer_0</sink_block_id><source_key>msg_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>gpredict_doppler_0</source_block_id><sink_block_id>gpredict_MsgPairToVar_0</sink_block_id><source_key>freq</source_key><sink_key>inpair</sink_key></connection>
<connection><source_block_id>msgtools_variable_to_msg_0</source_block_id><sink_block_id>generate_command</sink_block_id><source_key>out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_hdlc_framer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>satellites_nrzi_encode_0_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
