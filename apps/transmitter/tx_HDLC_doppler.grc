<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tx_HDLC_doppler</value></param>
<param><key>author</key><value>Dan Álvarez</value></param>
<param><key>description</key><value>This block transmits CSP commands in HDLC encoding and GMSK modulation.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Quetzal-1 Transmitter (w/ doppler correction)</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>RTC_label</value></param>
<param><key>value</key><value></value></param>
<param><key>gui_hint</key><value>0,2</value></param>
<param><key>label</key><value>RTC Data</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bit_rate</value></param>
<param><key>value</key><value>4800</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>choose_ax100_cmd</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>4,1</value></param>
<param><key>label</key><value>Select</value></param>
<param><key>labels</key><value>['TX OFF','TX ON','SEND FLASH &amp; RAM']</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0,1,2]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>choose_htr_cmd</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3,1</value></param>
<param><key>label</key><value>Select</value></param>
<param><key>labels</key><value>['HTR AUTO','HTR OFF','HTR ON']</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0,1,2]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>choose_pld_cmd</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>5,1</value></param>
<param><key>label</key><value>Select</value></param>
<param><key>labels</key><value>['SEND IMAGE','TAKE IMAGE','PLD FULL OPERATION']</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0,1,2]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>choose_ram_cmd</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>label</key><value>Select</value></param>
<param><key>labels</key><value>['CHANGE CDHS PERIOD','CHANGE WDT PERIOD', 'CHANGE ADM SOC LIMIT', 'CHANGE ADCS SOC LIMIT', 'CHANGE COMMS SOC LIMIT', 'CHANGE PLD SOC LIMIT', 'CHANGE HTR CYCLE TIME','CHANGE HTR ON TIME','CHANGE HTR OFF TIME','CHANGE ADM CYCLE TIME', 'CHANGE ADM BURN TIME', 'CHANGE ADM MAX CYCLES', 'CHANGE ADM WAIT TIME 1', 'CHANGE ADM WAIT TIME 2', 'ADM ENABLE/DISABLE', 'CHANGE COMMS CYCLE TIME', 'CHANGE PLD CYCLE TIME', 'CHANGE PLD OP MODE', 'CHANGE CAM RES', 'CHANGE CAM EXPOSURE', 'CHANGE CAM PIC SAVE TIME', 'PLD ENABLE/DISABLE', 'CHANGE RTC', 'SAVE RAM PARAMS TO FLASH']</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>choose_reset_cmd</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>2,1</value></param>
<param><key>label</key><value>Select</value></param>
<param><key>labels</key><value>['RESET OBC','RESET AX100','RESET EPS','RESET ADM','RESET ADCS','RESET PLD']</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0,1,2,3,4,5]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>cmd_type</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,5,1</value></param>
<param><key>label0</key><value>'Modify RAM Parameters'</value></param>
<param><key>label1</key><value>'Reset Modules'</value></param>
<param><key>label2</key><value>'Heater Control'</value></param>
<param><key>label3</key><value>'AX100 Control'</value></param>
<param><key>label4</key><value>'Payload Control'</value></param>
<param><key>label</key><value>Select Command Type</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>option4</key><value>4</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>command_data</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>7,0,1,2</value></param>
<param><key>label</key><value>Command data (press enter after input)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>day</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3,2</value></param>
<param><key>label</key><value>DD  </value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>437200000</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>hour</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,2</value></param>
<param><key>label</key><value>HH  </value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>log</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>minute</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>2,2</value></param>
<param><key>label</key><value>MM</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod_index</value></param>
<param><key>value</key><value>0.66667</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>month</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>4,2</value></param>
<param><key>label</key><value>MM</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>ptt</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>14,0,1,3</value></param>
<param><key>label</key><value>Push to Talk</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>test_cmd</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label0</key><value>'No'</value></param>
<param><key>label1</key><value>'Yes'</value></param>
<param><key>label</key><value>Sending test cmd?</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>year</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>5,2</value></param>
<param><key>label</key><value>YY  </value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>comment</key><value>Used to shift 
the DC peak 
500 kHz away 
from the signal.</value></param>
<param><key>freq</key><value>-100e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>comment</key><value>Uncomment this
in case you don't
want to transmit
anything.</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>comment</key><value>Packs the bytes
for the GFSK Mod.</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>comment</key><value>Converts the message
data into a stream
of unpacked bytes.</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>digital_gfsk_mod</key>
<param><key>id</key><value>digital_gfsk_mod_0</value></param>
<param><key>bt</key><value>0.5</value></param>
<param><key>comment</key><value>samples/symbol was
set to 4 because we
observed it worked.</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>sensitivity</key><value>3.14159265*mod_index/sps</value></param>
</block>
<block>
<key>digital_scrambler_bb</key>
<param><key>id</key><value>digital_scrambler_bb_0</value></param>
<param><key>comment</key><value>This corresponds to
a G3RUH scrambler
according to Estevez, D.</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>generate_command</value></param>
<param><key>choose_ax100_cmd</key><value>choose_ax100_cmd</value></param>
<param><key>choose_htr_cmd</key><value>choose_htr_cmd</value></param>
<param><key>choose_pld_cmd</key><value>choose_pld_cmd</value></param>
<param><key>choose_ram_cmd</key><value>choose_ram_cmd</value></param>
<param><key>choose_reset_cmd</key><value>choose_reset_cmd</value></param>
<param><key>cmd_type</key><value>cmd_type</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
import pylab
from gnuradio import gr
import pmt
import time
import serial


class msg_block(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
	"""This block sends commands within a CSP frame when a message is received on the input.
	
	Inputs:
	- ptt: when 0, tx is off; when 1, tx is on.
	- cmd_type: selects the command type from the 5 available types.
	- choose_ram_cmd: commands that change RAM parameters
	- choose_reset_cmd: commands to reset modules of the satellite
	- choose_ax100_cmd: commands to control the AX100 module
	- choose_htr_cmd: commands to control the battery heater
	- choose_pld_cmd: commands to take and download images with the payload module
	- command_data: contains the data that will be sent in a command, for example the RTC value
	- hour, minute, day, month, year: part of the RTC

	Outputs:
	- PMT type message containing a uint8 vector that contains the command encapsulated in the CSP frame.
	"""

	def __init__(self, ptt = 0, test_cmd = 0, cmd_type = 0, choose_ram_cmd = 0, choose_reset_cmd = 0, \
	choose_ax100_cmd = 0, choose_htr_cmd = 0, choose_pld_cmd = 0, packet_len = 0,   \
	command_data = 0, hour = 0, minute = 0, day = 0, month = 0, year = 0):
		"""arguments to this function show up as parameters in GRC"""
		gr.basic_block.__init__(
			self,
			name='Generate Command',   # will show up in GRC
			in_sig=None,
			out_sig=None
		)

		# serial port is used to control the USB relay that controles the switch from RX to TX
		# if /dev/ttyACM1 throws any errors, check to see if dialout is within your group permissions. Use:
		# $ groups ${USER}
		# $ sudo gpasswd --add ${USER} dialout

		# UNCOMMENT THESE LINES WHEN USING THE RF RELAY IN THE GROUND CONTROL STATION
		# SINCE THE RF RELAY IS CONTROLLED BY THE USB RELAY
		self.ser = serial.Serial(
			port='/dev/ttyUSB1',
			baudrate=9600,
			parity=serial.PARITY_NONE,
			stopbits=serial.STOPBITS_ONE,
			bytesize=serial.EIGHTBITS
		)

		# if an attribute with the same name as a parameter is found,
		# a callback is registered (properties work, too).		
		self.ptt = ptt
		self.cmd_type = cmd_type
		self.test_cmd = test_cmd
		self.choose_ram_cmd = choose_ram_cmd
		self.choose_reset_cmd = choose_reset_cmd
		self.choose_ax100_cmd = choose_ax100_cmd
		self.choose_htr_cmd = choose_htr_cmd
		self.choose_pld_cmd = choose_pld_cmd
		self.packet_len = packet_len
		self.command_data = command_data
		self.hour = hour
		self.minute = minute
		self.day = day
		self.month = month
		self.year = year

		self.message_port_register_out(pmt.intern('msg_out'))
		self.message_port_register_in(pmt.intern('msg_in'))
		self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

	def handle_msg(self, msg):
		if self.ptt == 1: # only transmits when PTT button is pressed 
			
			# SET RELAYS FOR TX MODE
			self.ser.write(bytearray([0xa0,0x01,0x01,0xa2]))	# sets relays in TX mode
			time.sleep(0.1)									# give relays time to switch

			# RESET PAYLOD CMD VERIFICATION FLAG
			pldCmdFlag = False
			# RESET RESET CMD VERIFICATION FLAG
			rstCmdFlag = False

			# GENERATE CSP HEADER	
				# priority = 1
				# source = 7
				# destination = 1
				# destination port = 25		
				# source port = 7
				# reserved = 0
				# HMAC = 0
				# XTEA = 0
				# RDP = 0
				# CRC = 0

			# CSP: 01 00111 00001 011001 000111 00000000

			priority = int('{0:02b}'.format(1), 2)	
			source = int('{0:05b}'.format(7), 2)	
			destination = int('{0:05b}'.format(1), 2)
			destination_port = int('{0:06b}'.format(25), 2)
			source_port = int('{0:06b}'.format(7), 2)
			reserved = int('{0:04b}'.format(0), 2)
			hmac = int('{0:01b}'.format(0), 2)
			xtea = int('{0:01b}'.format(0), 2)
			RDP = int('{0:01b}'.format(0), 2)
			CRC = int('{0:01b}'.format(0), 2)

			CSP_header = (priority &lt;&lt; 30) | (source &lt;&lt; 25) | (destination &lt;&lt; 20) | (destination_port &lt;&lt; 14) | \
			(source_port &lt;&lt; 8) | (reserved &lt;&lt; 4) | (hmac &lt;&lt; 3) | (xtea &lt;&lt; 2) | (RDP &lt;&lt; 1) | CRC

			byte1 = np.array([CSP_header &amp; 0xFF],np.uint8)
			byte2 = np.array([(CSP_header &gt;&gt; 8) &amp; 0xFF],np.uint8) 
			byte3 = np.array([(CSP_header &gt;&gt; 16) &amp; 0xFF],np.uint8)
			byte4 = np.array([(CSP_header &gt;&gt; 24) &amp; 0xFF],np.uint8)

			# GENERATE VERIFICATION CODE
			# verification code is 0x6F, 0x5D

			verByte1 = np.array([0x6f],np.uint8)
			verByte2 = np.array([0x5d],np.uint8)


			# COMMAND DICTIONARIES
			# TAB-CDH-001 contains all the commands listed below

			# commands to change ram parameters
			# 0 = CDHS Cycle Time
			# 1 = CDHS WDT Time
			# 2 = ADM SOC Limit
			# 3 = ADCS SOC Limit
			# 4 = COMMS SOC Limit
			# 5 = PLD SOC Limit
			# 6 = HEATER Cycle Time
			# 7 = HEATER Emergency ON Time
			# 8 = HEATER Emergency OFF Time
			# 9 = ADC Cycle Time
			# 10 = ADM Burn Time
			# 11 = ADM Max Cycles
			# 12 = ADM Wait Time 1
			# 13 = ADM Wait Time 2
			# 14 = ADM Enable/Disable
			# 15 = COMMS Cycle Time
			# 16 = PLD Cycle Time
			# 17 = PLD Operation Mode
			# 18 = Camera Resolution (not implemented on board satellite)
			# 19 = Camera Exposition Time (not implemented on board satellite)
			# 20 = Camera Picture Save Time
			# 21 = PLD Enable/Disable
			# 22 = Change RTC
			# 23 = Save RAM parameters to FLASH
			ram_cmd = {\
			0: [0xa9,0xa9,self.command_data], \
			1: [0xa9,0xaa,self.command_data], \
			2: [0xa9,0xab,self.command_data], \
			3: [0xa9,0xac,self.command_data], \
			4: [0xa9,0xad,self.command_data], \
			5: [0xa9,0xae,self.command_data], \
			6: [0xa9,0xaf,self.command_data], \
			7: [0xa9,0xb1,self.command_data], \
			8: [0xa9,0xb2,self.command_data], \
			9: [0xa9,0xb3,self.command_data], \
			10: [0xa9,0xb4,self.command_data], \
			11: [0xa9,0xb5,self.command_data], \
			12: [0xa9,0xb6,self.command_data], \
			13: [0xa9,0xb7,self.command_data], \
			14: [0xa9,0xb8,self.command_data], \
			15: [0xa9,0xb9,self.command_data], \
			16: [0xa9,0xba,self.command_data], \
			17: [0xa9,0xbb,self.command_data], \
			18: [0xa9,0xbc,self.command_data], \
			19: [0xa9,0xbd,self.command_data], \
			20: [0xa9,0xbe,self.command_data], \
			21: [0xa9,0xbf,self.command_data], \
			22: [0xa9,0xc9,self.hour,self.minute,self.day,self.month,self.year], \
			23: [0xa9,0xca]}

			# commands to reset specific modules
			# 0 = obc reset
			# 1 = ax100 reset
			# 2 = eps reset
			# 3 = adm reset
			# 4 = adcs reset
			# 5 = pld reset
			rst_cmd = {\
			0: [0xb9,0xa9], \
			1: [0xb9,0xaa], \
			2: [0xb9,0xab], \
			3: [0xb9,0xac], \
			4: [0xb9,0xad], \
			5: [0xb9,0xae]}

			# commands to operate heater
			# 0 = htr auto
			# 1 = htr off
			# 2 = htr on
			htr_cmd = {\
			0: [0xc9,0x41], \
			1: [0xc9,0x44], \
			2: [0xc9,0x55]}

			# commands to operate AX100
			# 0 = tx disable
			# 1 = tx enable
			# 2 = send ram/flash parameters
			ax100_cmd = {\
			0: [0xe9,0xa9], \
			1: [0xe9,0xaa], \
			2: [0xe9,0xab]}

			# commands to operate Payload
			# 0 = download image
			# 1 = take image
			# 2 = pld full operation
			pld_cmd = {\
			0: [0xf9,0xa9], \
			1: [0xf9,0xaa], \
			2: [0xf9,0xab]}

			# GENERATE COMMAND DEPENDING ON USER SELECTIONS
			
			if self.cmd_type == 0:
				command = np.array(ram_cmd[self.choose_ram_cmd],np.uint8)
			elif self.cmd_type == 1:
				command = np.array(rst_cmd[self.choose_reset_cmd],np.uint8)
				#rstCmdFlag = True
			elif self.cmd_type == 2:
				command = np.array(htr_cmd[self.choose_htr_cmd],np.uint8)
			elif self.cmd_type == 3:
				command = np.array(ax100_cmd[self.choose_ax100_cmd],np.uint8)
			elif self.cmd_type == 4:
				command = np.array(pld_cmd[self.choose_pld_cmd],np.uint8)
				#pldCmdFlag = True

			# FORM CSP PACKET

			transmit = np.concatenate([byte4,byte3,byte2,byte1,verByte1,verByte2,command])		# concatenates CSP Header and command into single frame  

			# FORM FAKE CSP PACKET
			
			commandFake = np.array([0x00, 0x00],np.uint8)
			transmitFake = np.concatenate([byte4,byte3,byte2,byte1,verByte1,verByte2,commandFake])

			# CALCULATE COMMAND LENGTH

			self.packet_len = len(transmit)

			# TRANSMIT

			if self.test_cmd:
				# HARD CODE HERE WHATEVER TEST COMMAND YOU WANT
				test_commands = [
					[0xa9, 0xae, 68],
					[0xa9, 0xae, 69],
					[0xa9, 0xb8, 0],
					[0xa9, 0xb8, 0],
					[0xa9, 0xac, 41],
					[0xa9, 0xac, 42],
					[0xa9, 0xac, 43]
				]
				preample_test_cmd = np.concatenate([byte4,byte3,byte2,byte1,verByte1,verByte2])
				for command in test_commands:
					to_append = np.array(command,np.uint8)
					transmit = np.append(preample_test_cmd, to_append)
					self.message_port_pub(pmt.intern('msg_out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(transmit)))
			elif pldCmdFlag or rstCmdFlag:
				# THIS IS OBSOLETE
				# IF ITS A PAYLOD OR RESET COMMAND, SEND 3 INVALID + 1 VALID + 2 INVALID
				for i in range(0,3):
					self.message_port_pub(pmt.intern('msg_out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(transmitFake)))
				self.message_port_pub(pmt.intern('msg_out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(transmit)))
				self.message_port_pub(pmt.intern('msg_out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(transmitFake)))
				self.message_port_pub(pmt.intern('msg_out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(transmitFake)))
			else:
				# IF ANY OTHER COMMAND, SEND N VALID COMMANDS (BURST)
				for i in range(0,7):
					self.message_port_pub(pmt.intern('msg_out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(transmit)))
				#self.message_port_pub(pmt.intern('msg_out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(transmitFake)))			

			# PRINT TO TERMINAL

			print "\n"
			print "Command: ", transmit
			print "\n"

			# BRING BACK RELAYS INTO RX MODE
			if self.test_cmd:
				time.sleep(0.93)										# if test command, wait a little bit longer
			else:
				time.sleep(0.93)									# if normal set of commands, wait a little less
			self.ser.write(bytearray([0xa0,0x01,0x00,0xa1]))		# sets relays in RX mode

	def work(self, input_items, output_items):
		pass
</value></param>
<param><key>command_data</key><value>command_data</value></param>
<param><key>comment</key><value>Creates commands
encapsulated in a CSP
frame.

Remember to uncomment
lines 53-59, 86-87 and 261-262
to activate the USB Relay that
controls the RF Relay.</value></param>
<param><key>day</key><value>day</value></param>
<param><key>hour</key><value>hour</value></param>
<param><key>minute</key><value>minute</value></param>
<param><key>month</key><value>month</value></param>
<param><key>packet_len</key><value>0</value></param>
<param><key>ptt</key><value>ptt</value></param>
<param><key>test_cmd</key><value>test_cmd</value></param>
<param><key>year</key><value>year</value></param>
</block>
<block>
<key>gpredict_MsgPairToVar</key>
<param><key>id</key><value>gpredict_MsgPairToVar_0</value></param>
<param><key>target</key><value>freq</value></param>
</block>
<block>
<key>gpredict_doppler</key>
<param><key>id</key><value>gpredict_doppler_0</value></param>
<param><key>comment</key><value>Only used when we wish to
correct for doppler shift
on TX.</value></param>
<param><key>gpredict_port</key><value>4532</value></param>
<param><key>gpredict_host</key><value>localhost</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>msgtools_variable_to_msg</key>
<param><key>id</key><value>msgtools_variable_to_msg_0</value></param>
<param><key>comment</key><value>Keys the transmitter.
It sends a message
when the ptt variable
changes.</value></param>
<param><key>key</key><value>1</value></param>
<param><key>value</key><value>ptt</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>freq0</key><value>freq+100e3</value></param>
<param><key>if_gain0</key><value>47</value></param>
<param><key>gain0</key><value>14</value></param>
<param><key>comment</key><value>Ensure the correct
hackrf is selected in
device arguments.

The TX HackRF's
argument is
hackrf=36135f.</value></param>
<param><key>args</key><value>hackrf=36135f</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>comment</key><value>Sets the baud
rate of the transmitted
data to 4800 bps.</value></param>
<param><key>decim</key><value>bit_rate*sps</value></param>
<param><key>interp</key><value>samp_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>satellites_hdlc_framer</key>
<param><key>id</key><value>satellites_hdlc_framer_0</value></param>
<param><key>comment</key><value>Adds start and stop
flags, the CRC and
performs bit stuffing.</value></param>
<param><key>postamble_bytes</key><value>0</value></param>
<param><key>preamble_bytes</key><value>50</value></param>
</block>
<block>
<key>satellites_nrzi_encode</key>
<param><key>id</key><value>satellites_nrzi_encode_0_0</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>digital_gfsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_scrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gfsk_mod_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_scrambler_bb_0</source_block_id><sink_block_id>satellites_nrzi_encode_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>generate_command</source_block_id><sink_block_id>satellites_hdlc_framer_0</sink_block_id><source_key>msg_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>gpredict_doppler_0</source_block_id><sink_block_id>gpredict_MsgPairToVar_0</sink_block_id><source_key>freq</source_key><sink_key>inpair</sink_key></connection>
<connection><source_block_id>msgtools_variable_to_msg_0</source_block_id><sink_block_id>generate_command</sink_block_id><source_key>out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_hdlc_framer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>satellites_nrzi_encode_0_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
